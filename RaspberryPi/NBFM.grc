options:
  parameters:
    author: bd-ats
    generate_options: qt_gui
    id: NBFM
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: doppler_start_time
  id: variable
  parameters:
    value: '1689516592'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '145955000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '576000'
  states: {}
- name: variable_band_pass_filter_taps_0
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: '10000'
    low_cutoff_freq: '-10000'
    samp_rate: samp_rate
    type: complex_band_pass
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5e3
    quad_rate: '192000'
    tau: '75e-6'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-50'
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: /home/bd-ats/radio/recording/recording.wav
    format: FORMAT_WAV
    samp_rate: '48000'
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '3'
    taps: variable_band_pass_filter_taps_0
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: satellites_doppler_correction_0
  id: satellites_doppler_correction
  parameters:
    samp_rate: samp_rate
    t0: doppler_start_time
  states: {}

connections:
- [analog_nbfm_rx_0, '0', blocks_wavfile_sink_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_nbfm_rx_0, '0']
- [fft_filter_xxx_0, '0', analog_simple_squelch_cc_0, '0']
- [rtlsdr_source_0, '0', satellites_doppler_correction_0, '0']
- [satellites_doppler_correction_0, '0', fft_filter_xxx_0, '0']

metadata:
  file_format: 1
